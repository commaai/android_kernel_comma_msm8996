## drivers/comma/Kconfig
```kconfig
config MACH_COMMA
        bool "Enable Support for Comma boards"
	select IIO_TRIGGERED_BUFFER
```
